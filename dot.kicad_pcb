# Repository IoTPanic/udpx-dot

File README.md:

# udpx-dot

_This is an Open Source hardware project, and meant for others to make their own or modify. If you would like to support the developers of the UDPX project (Including the ESP firmware, smartphone app, web interface, PIXELS protocol, and little stream network protocol), we will be posting a offical tindie link here shortly._

The UDPX ESP32 PCB allows anyone to use the UDPX project without any hassle. It can either be bought or assembled yourself as all the parts are easy to assemble even though they are all SMD; no oven or hot plates requierd! There are a few features to using this PCB over just some random development board, which are the following-

* USB-C power with resistors that can be configured to 1.5A or 3A input which allows for smaller strips or panels to be powered over a standard USB-C phone charger or power bank. This conenction can also be used for programming.
* Large input capacitors that allow for a panel or multiple strips to turn off without voltage dips and cause any issues.
* A large P-Channel MOSFET for input polarity protection which allows for sizable 5VDC power supplies to be attached.
* Blade automotive fuse for user selctable trip currents and easy changing.
* LEDs and Buttons useful for managing the UDPX firmware such as enabling BLE or controlling Wi-Fi along with a usr button and LED.
* Level shifter for use with the WS2812/WS2812B LEDs which is required as a part of the communication protocol.
* SD-card for firmware update without requiring a IDE installation as well as pre-defined patterens.
* Header for a external serial connection such as RS-485.

# Pin Usage

# Sister Repositories

* UDPX ESP32 Firmware @martinfasani - https://github.com/martinberlin/udpx
* PIXELS Application layer @IoTPanic - https://github.com/IoTPanic/pixels
* Web Application @hputzek - https://github.com/hputzek/little-stream-protocol
* Mobile App @martinfasani - https://github.com/martinberlin/udpx-app

## KiCad design dot.kicad_pcb

Parts:
C1, C3, C11: 1uF; C_0805_2012Metric
C2, C5, C6: 1mF; CP_Elec_8x10.5
C4: 0.2uF; C_0805_2012Metric
C7: 100uF; CP_Elec_6.3x3.9
C8, C9, C10, C12: 10uF; C_0805_2012Metric
D1: D; D_SOD-123F
D2: SP0503BAHT; SOT-143
F1: Blade Fuse; Fuseholder_Blade_Mini_Keystone_3568
H1, H2, H3: MountingHole; MountingHole_2.5mm
J1: PWR; TerminalBlock_bornier-4_P5.08mm
J2: GPIO; PinHeader_1x05_P2.54mm_Vertical
J3: EX_SERIAL; PinHeader_1x05_P2.54mm_Vertical
J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4085
L1: 1uH; L_1008_2520Metric
Q1: SQM40031EL; TO-263-2
Q2, Q3: MMBT2222; SOT-23
R1, R2, R3, R6, R7: 10K; R_0805_2012Metric
R4, R5: 5.1K; R_0805_2012Metric
SW1: SW_Push; SW_Push_1P1T_NO_CK_KMR2
U1: ESP32-WROOM-32D; ESP32-WROOM-32
U2: ADP2108AUJ-3.3; TSOT-23-5
U3: CP2104; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm

Connections:
+3V3: C1.1, C3.1, C10.1, C11.1, C12.1, J3.1, L1.2, R2.1, U1.2 (VDD), U2.4 (FB), U3.5, U3.19; also elsewhere on the board
+5V: C2.1, C5.1, C6.1, C7.1, C8.1, C9.1, D1.1 (K), Q1.3 (S), U2.1 (Vin), U2.3 (EN); also elsewhere on the board
/BUT_BLE: U1.8 (IO32); also elsewhere on the board
/BUT_CFG: U1.12 (IO27); also elsewhere on the board
/BUT_USER: U1.11 (IO26); also elsewhere on the board
/DTR: Q2.2 (E), R7.2, U3.15
/GPIO0: Q2.3 (C), U1.25 (IO0)
/LED_BLE: U1.9 (IO33); also elsewhere on the board
/LED_USER: U1.7 (IO35); also elsewhere on the board
/LED_WIFI: U1.6 (IO34); also elsewhere on the board
/RESET: C4.1, Q3.3 (C), R2.2, SW1.1, U1.3 (EN)
/RTS: Q3.2 (E), R6.2, U3.16
/RX: U1.34 (RXD0/IO3), U3.3
/SD_CLK: U1.20 (SCK/CLK); also elsewhere on the board
/SD_CMD: U1.19 (SCS/CMD); also elsewhere on the board
/SD_D0: U1.21 (SDO/SD0); also elsewhere on the board
/SD_D1: U1.22 (SDI/SD1); also elsewhere on the board
/SD_D2: U1.17 (SHD/SD2); also elsewhere on the board
/SD_D3: U1.18 (SWP/SD3); also elsewhere on the board
/STRIP0: U1.10 (IO25); also elsewhere on the board
/STRIP1: U1.37 (IO23); also elsewhere on the board
/STRIP2: U1.36 (IO22); also elsewhere on the board
/STRIP3: U1.33 (IO21); also elsewhere on the board
/STRIP4: U1.31 (IO19); also elsewhere on the board
/STRIP5: J3.4, U1.30 (IO18); also elsewhere on the board
/STRIP6: J3.3, U1.28 (IO17); also elsewhere on the board
/STRIP7: J3.2, U1.27 (IO16); also elsewhere on the board
/TX: U1.35 (TXD0/IO1), U3.4
unnamed: D1.2 (A), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), R4.1, R5.1
unnamed: D2.2 (K), J4.A6 (D+), J4.B6 (D+), U3.6
unnamed: D2.3 (K), J4.A7 (D-), J4.B7 (D-), U3.7
unnamed: D2.4 (K), J4.B5 (CC2), R5.2
unnamed: F1.1, Q1.2 (D)
unnamed: J2.1, U1.26 (IO4)
unnamed: J2.2, U1.29 (IO5)
unnamed: J2.3, U1.14 (IO12)
unnamed: J2.4, U1.13 (IO14)
unnamed: J2.5, U1.23 (IO15)
unnamed: J4.A5 (CC1), R4.2
unnamed: L1.1, U2.5 (SW)
unnamed: Q2.1 (B), R6.1
unnamed: Q3.1 (B), R7.1
unnamed: R1.1, U1.5 (SENSOR_VN)
unnamed: R3.1, U1.4 (SENSOR_VP)

Notes on the sheet:
1.5A
100uF - EEE-HC1C101XP 1mF - EEE-FK0J102P
LQM2HPN1R0MG0L

Parts:
C13: 1uF; C_0805_2012Metric
D3: RED; LED_1206_3216Metric
D4: BLUE; LED_1206_3216Metric
D5: GREEN; LED_1206_3216Metric
D6: ORANGE; LED_1206_3216Metric
J5: Micro_SD_Card_Det; microSD_HC_Hirose_DM3BT-DSF-PEJS
J6: STRIP0; PinHeader_1x03_P2.54mm_Vertical
J7: STRIP1; PinHeader_1x03_P2.54mm_Vertical
J8: STRIP2; PinHeader_1x03_P2.54mm_Vertical
J9: STRIP3; PinHeader_1x03_P2.54mm_Vertical
J10: STRIP4; PinHeader_1x03_P2.54mm_Vertical
J11: STRIP5; PinHeader_1x03_P2.54mm_Vertical
J12: STRIP6; PinHeader_1x03_P2.54mm_Vertical
J13: STRIP7; PinHeader_1x03_P2.54mm_Vertical
R8, R10, R12, R13: 10K; R_0805_2012Metric
R9: 470; R_0805_2012Metric
R11: 10; R_0805_2012Metric
R14, R15: R; R_0805_2012Metric
SW2: BLE; SW_Push_1P1T_NO_CK_KMR2
SW3: CONFIG_RST; SW_Push_1P1T_NO_CK_KMR2
SW4: USER; SW_Push_1P1T_NO_CK_KMR2
U4: 74HCT245; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+3V3: C13.1, D3.2 (A), J5.4 (VDD), R8.1, R10.1, R12.1, R13.1; also elsewhere on the board
+5V: J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, U4.1 (DIR), U4.20 (VCC); also elsewhere on the board
/BUT_BLE: R13.2, SW2.1; also elsewhere on the board
/BUT_CFG: R12.2, SW3.1; also elsewhere on the board
/BUT_USER: R10.2, SW4.1; also elsewhere on the board
/LED_BLE: D4.2 (A); also elsewhere on the board
/LED_USER: D6.2 (A); also elsewhere on the board
/LED_WIFI: D5.2 (A); also elsewhere on the board
/SD_CLK: J5.5 (CLK); also elsewhere on the board
/SD_CMD: J5.3 (CMD); also elsewhere on the board
/SD_D0: J5.7 (DAT0); also elsewhere on the board
/SD_D1: J5.8 (DAT1); also elsewhere on the board
/SD_D2: J5.1 (DAT2); also elsewhere on the board
/SD_D3: J5.2 (DAT3/CD); also elsewhere on the board
/SD_DET: J5.10 (DET_A), R8.2
/STRIP0: U4.9 (A8); also elsewhere on the board
/STRIP1: U4.8 (A7); also elsewhere on the board
/STRIP2: U4.7 (A6); also elsewhere on the board
/STRIP3: U4.6 (A5); also elsewhere on the board
/STRIP4: U4.5 (A4); also elsewhere on the board
/STRIP5: U4.4 (A3); also elsewhere on the board
/STRIP6: U4.3 (A2); also elsewhere on the board
/STRIP7: U4.2 (A1); also elsewhere on the board
unnamed: D3.1 (K), R9.1
unnamed: D4.1 (K), R11.1
unnamed: D5.1 (K), R14.1
unnamed: D6.1 (K), R15.1
unnamed: J6.2, U4.18 (B1)
unnamed: J7.2, U4.17 (B2)
unnamed: J8.2, U4.16 (B3)
unnamed: J9.2, U4.15 (B4)
unnamed: J10.2, U4.14 (B5)
unnamed: J11.2, U4.13 (B6)
unnamed: J12.2, U4.12 (B7)
unnamed: J13.2, U4.11 (B8)

Notes on the sheet:
POWER
BLE
WIFI
USER
Or could make the LEDs a Neopixel

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
Board: 2 copper layers, 98.0 x 64.0 mm, 63 parts (0 on the bottom side), 59 nets.

Other parts of the board:
UDPX: UDPX_small

## Commit log

2019-12-14 Made printed PDF for github viewing
2019-12-14 Added a level shifter and removed a channel
2019-12-15 About to change the entire damn thing to handle more current
2019-12-15 README.md update
2020-01-20 Ordered files
2020-03-29 Updated schematic to use right footprint, change fuse holder, and removal of caps
2020-03-31 Almost done with second rev
